# Repository mailofthe/ENGR240-Lab-4

## EAGLE design iceWerx Carrier.brd

Parts:
D3: LED5MM
DS1: LDQ-M282RI; LDQM282RI
DS2: LTA-1000G; DIPS762W50P254L2527H825Q20N
J1, J2, J3: PMOD-SOCKET-FOR-HOST-BOARD
MT1, MT2, MT3, MT4: MOUNTING_HOLE-125_250_ROUND; MT_125_250
PL2: ICEWERX-PL2; TE_4-1734506-1
PL3: ICEWERX-PL3; TE_4-1734506-1
Q1, Q2, Q3, Q4: NX2301P; SOT95P230X110-3N
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19: R-US_0204/5; 0204/5
S1, S2, S3, S4: OS102011MS2QN1; SW_OS102011MS2QN1
S5, S6, S7, S8: 1825910-7; SW_1825910-7

Connections:
3.3V: J1.6, J1.12, J2.6, J2.12, J3.6, J3.12, PL2.4 (3V3), Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), R19.2
BAR_1: PL3.27 (C10), R1.1
BAR_2: PL3.28 (C11), R2.1
BAR_3: PL3.29 (A10), R3.1
BAR_4: PL3.30 (D10), R4.1
BAR_5: PL3.31 (D6), R5.1
BAR_6: PL3.32 (D7), R6.1
BAR_7: PL3.33 (C7), R7.1
BAR_8: PL3.34 (C6), R8.1
BAR_9: PL3.35 (A7), R9.1
BAR_10: PL3.36 (A6), R10.1
BUTTON_1: PL2.13 (M3), S5.1
BUTTON_2: PL2.15 (M1), S6.1
BUTTON_3: PL2.17 (K3), S7.1
BUTTON_4: PL2.19 (J1), S8.1
DIGIT_1: PL2.12 (P1), Q1.1 (G)
DIGIT_1_A: DS1.12 (DIG1_COM_A), Q1.3 (D)
DIGIT_2: PL2.14 (N1), Q2.1 (G)
DIGIT_2_A: DS1.9 (DIG2_COM_A), Q2.3 (D)
DIGIT_3: PL2.16 (L1), Q3.1 (G)
DIGIT_3_A: DS1.8 (DIG3_COM_A), Q3.3 (D)
DIGIT_4: PL2.18 (J3), Q4.1 (G)
DIGIT_4_A: DS1.6 (DIG4_COM_A), Q4.3 (D)
GND: D3.K (C), DS2.11 (CATHODE_K), DS2.12 (CATHODE_J), DS2.13 (CATHODE_H), DS2.14 (CATHODE_G), DS2.15 (CATHODE_F), DS2.16 (CATHODE_E), DS2.17 (CATHODE_D), DS2.18 (CATHODE_C), DS2.19 (CATHODE_B), DS2.20 (CATHODE_A), J1.5, J1.11, J2.5, J2.11, J3.5, J3.11, PL2.6 (GND), PL3.2 (GND), S1.3, S2.3, S3.3, S4.3, S5.3, S6.3, S7.3, S8.3
unnamed: DS2.8 (ANODE_H), R8.2
unnamed: DS2.1 (ANODE_A), R1.2
unnamed: DS2.2 (ANODE_B), R2.2
unnamed: DS2.3 (ANODE_C), R3.2
unnamed: DS2.4 (ANODE_D), R4.2
unnamed: DS2.5 (ANODE_E), R5.2
unnamed: DS2.6 (ANODE_F), R6.2
unnamed: DS2.9 (ANODE_J), R9.2
unnamed: DS2.7 (ANODE_G), R7.2
unnamed: DS2.10 (ANODE__K), R10.2
unnamed: DS1.7 (B_K), R18.1
unnamed: DS1.10 (F_K), R17.1
unnamed: DS1.11 (A_K), R16.1
unnamed: DS1.1 (E_K), R11.2
unnamed: DS1.2 (D_K), R12.2
unnamed: DS1.3 (DP1_K), R13.2
unnamed: DS1.4 (C_K), R14.2
unnamed: DS1.5 (G_K), R15.2
unnamed: D3.A, R19.1
PMOD_1_1: J1.1, PL3.3 (M12)
PMOD_1_2: J1.2, PL3.5 (N14)
PMOD_1_3: J1.3, PL3.7 (K12)
PMOD_1_4: J1.4, PL3.9 (H11)
PMOD_1_5: J1.7, PL3.4 (P8)
PMOD_1_6: J1.8, PL3.6 (P14)
PMOD_1_7: J1.9, PL3.8 (L12)
PMOD_1_8: J1.10, PL3.10 (L14)
PMOD_2_1: J2.1, PL3.11 (J12)
PMOD_2_2: J2.2, PL3.13 (G12)
PMOD_2_3: J2.3, PL3.15 (F12)
PMOD_2_4: J2.4, PL3.17 (E12)
PMOD_2_5: J2.7, PL3.12 (K14)
PMOD_2_6: J2.8, PL3.14 (H12)
PMOD_2_7: J2.9, PL3.16 (G14)
PMOD_2_8: J2.10, PL3.18 (F14)
PMOD_3_1: J3.1, PL3.19 (D12)
PMOD_3_2: J3.2, PL3.21 (C12)
PMOD_3_3: J3.3, PL3.23 (B14)
PMOD_3_4: J3.4, PL3.25 (A11)
PMOD_3_5: J3.7, PL3.20 (E14)
PMOD_3_6: J3.8, PL3.22 (D14)
PMOD_3_7: J3.9, PL3.24 (C14)
PMOD_3_8: J3.10, PL3.26 (A12)
SEGMENT_A: PL2.21 (H1), R16.2
SEGMENT_B: PL2.23 (G1), R18.2
SEGMENT_C: PL2.25 (E1), R14.1
SEGMENT_D: PL2.27 (C1), R12.1
SEGMENT_DP: PL2.35 (A4), R13.1
SEGMENT_E: PL2.29 (C3), R11.1
SEGMENT_F: PL2.31 (A1), R17.2
SEGMENT_G: PL2.33 (A3), R15.1
SWITCH_1: PL2.5 (M7), S1.2
SWITCH_2: PL2.7 (M6), S2.2
SWITCH_3: PL2.9 (P3), S3.2
SWITCH_4: PL2.11 (P2), S4.2

Notes on the sheet:
N/C

Board: 2 copper layers, 76.2 x 50.8 mm, 43 parts (7 on the bottom side), 79 nets.
